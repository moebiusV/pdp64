## qemu/hw-pdp64/Kconfig
```kconfig
config PDP64_VIRT
    bool
    default y
    depends on PDP64
    select PCI_EXPRESS_GENERIC_BRIDGE
```
